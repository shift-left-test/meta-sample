require cmake-project.inc
